	AREA START,CODE,READONLY
	ENTRY
	CODE32
	
BUZZER_TEST
BUZZER_INIT
	;设置GPIO管脚为输出模式，GPD0CON[0]
	LDR R0,=0XE02000A0			
	LDR R1,=0X1					;十六进制0x1对应二进制0001				 	
	STR R1,[R0]
	
BUZZER_ON	
	;设置GPD0DAT[0]为高电平，buzzer发声
	LDR R0,=0XE02000A4		
	LDR R1,=0X1
	STR R1,[R0]
	
	;模拟sleep，延时
delay1
	MOV R4,#0XFFFFFFF
LOOP1
	SUBS R4, R4, #1
	BNE LOOP1
	
BUZZER_OFF	
	;设置GPD0DAT[0]为低电平，buzzer停止发声
	LDR R0,=0XE02000A4
	LDR R1,=0X0
	STR R1,[R0]
	

delay2
	MOV R4,#0XFFFFFFF
LOOP2
	SUBS R4, R4, #1
	BNE LOOP2
	
	B BUZZER_ON
	
	END